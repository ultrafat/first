# Keil uVision project test1.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: MK60DN512xxx10 Freescale
  pack: Keil.Kinetis_K60_DFP.1.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) IRAM2(0x1FFF0000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: test1 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\SRC\STARTUP;..\SRC\SYSTEM\DELAY;..\SRC\SYSTEM\GPIO;..\SRC\SYSTEM\SYS;..\SRC\SYSTEM\UART;..\SRC\SYSTEM\WDOG
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  memory RVCT10: RAM 0x1fff0000 size 0x10000
  group USER
    ../SRC/USER/: main.c
  group SYSEM
    ../SRC/SYSTEM/DELAY/: delay.c
    ../SRC/SYSTEM/GPIO/: gpio.c
    ../SRC/SYSTEM/SYS/: sys.c
    ../SRC/SYSTEM/UART/: uart.c
    ../SRC/SYSTEM/WDOG/: wdog.c
  group STARUP
    ../SRC/STARTUP/: system_MK60DZ10.c startup_MK60DZ10.s
